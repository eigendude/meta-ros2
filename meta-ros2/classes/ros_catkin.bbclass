# Copyright (c) 2019 LG Electronics, Inc.

# Because inherits are resolved at parse time, we need to provide an empty
# ros_catkin class to avoid breaking unused recipes that require ROS 1.
