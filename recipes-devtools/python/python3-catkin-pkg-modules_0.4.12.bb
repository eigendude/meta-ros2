FILESEXTRAPATHS_prepend := "${THISDIR}/python-catkin-pkg-modules:"

require python-catkin-pkg-modules.inc

inherit setuptools3
