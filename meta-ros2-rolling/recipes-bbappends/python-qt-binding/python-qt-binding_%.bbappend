# Copyright (c) 2023 Wind River Systems, Inc.

DEPENDS += "sip-native python3-pyqt5-native"
