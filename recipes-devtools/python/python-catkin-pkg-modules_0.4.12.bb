require python-catkin-pkg-modules.inc

inherit setuptools
