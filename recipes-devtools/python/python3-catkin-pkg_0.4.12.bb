FILESEXTRAPATHS_prepend := "${THISDIR}/python-catkin-pkg:"

require python-catkin-pkg.inc

inherit setuptools3
